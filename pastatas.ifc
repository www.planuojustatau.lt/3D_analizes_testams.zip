Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement [Architecture], Option [IfcExportBaseQuantities: Off], Option [IfcExportElementOnOffAndFrozenLayers: On], Option [IfcExplodeExternalReferences: Off], Option [IfcTesselateBSplineCurvesAndSurfaces: Off], Option [IfcExportSweptSolidAsBRep: Off], Option [IfcExportProfileCenterOfGravity: Off], Option [IfcExportMultiPlyElementsAsAggregated: Off], Option [IfcExportTesselation: 0.000000], Option [IfcCreateUniqueGuidForBlocks: On], Option [IfcCreateUniqueGuidForXrefs: On], Option [IfcExportSubtractOpenings: Off], Option [IfcExportAllVisibilityStates: Off]
File name: D:\\CAD_testai\\vienas_pastatas.ifc
Time: 2026-03-25T09:31:49
Author: Undefined
Organization: Undefined
Written by: BricsCAD BIM 26.1.08
Made in: BricsCAD BIM 26.1.08
Authorization: Undefined

# IfcSite, Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 in

# IfcBuilding, Site
ElevationOfRefHeight: 0 in; ElevationOfTerrain: 0 in

# IfcBuildingElementProxy (47)
In: Site
New PropertySet - isore: 1
Name
7EC
7EF
7F2
7F5
7F8
7FB
7FE
804
80A
80D
810
813
816
81C
81F
825
82E
831
834
837
83A
843
846
849
84C
858
85B
85E
861
86D
870
873
876
87C
87F
882
885
88B
88E
891
894
897
15B2
15C1
15C4
15C7
15CA

# IfcBuildingElementProxy: ss, 1458
In: Site
New PropertySet - isore: 1
